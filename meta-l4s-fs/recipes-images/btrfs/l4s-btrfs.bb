require recipes-core/image/l4s-core-image.bb

WKS_FILE = "l4s-btrfs.wic"
IMAGE_FSTYPES = "wic wic.bmap"