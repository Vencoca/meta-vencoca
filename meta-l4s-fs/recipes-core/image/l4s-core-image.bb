require recipes-core/images/core-image-minmal.bb

IMAGE_INSTALL:append = " measure"